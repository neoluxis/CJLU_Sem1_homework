# Keil uVision project LearningProject_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LearningProject_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\LearningProject_1
  group src
    ./src/: Main.c
