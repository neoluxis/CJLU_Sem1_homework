# Keil uVision project calc.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: calc
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Keys;.\Matrix;.\Shumag;.\Timer;.\Main;.\Tool;.\Calculator
  group Main
    ./Main/: main.c
  group Timer
    ./Timer/: Timer.c
  group Shumag
    ./Shumag/: Shumag.c
  group Keys
    ./Keys/: Keys.c
  group Matrix
    ./Matrix/: Matrix.c
  group Tool
    ./Tool/: Tool.c
  group Calculator
    ./Calculator/: Calculator.c
